# Keil uVision project fros_mock.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: frot_mock
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User;..\include;..\portal\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
